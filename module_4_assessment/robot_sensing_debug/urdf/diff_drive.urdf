Commit message: Task_4 Completed

File: module_4_assessment/robot_sensing_debug/urdf/diff_drive.urdf (robot description, URDF)
Before this commit: robot dolly, 6 links, 5 joints
Joints:
- joint lidar_joint: origin xyz=-0.285 0 0.075 rpy=0 0.0 1.57 -> xyz=-0.285 0 0.075 rpy=0.0 0.0 0.0
